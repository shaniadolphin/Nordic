# Keil uVision project oled.uvprojx, settings and files
target nrf52832_xxaa (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.9.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: oled +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: BSP_DEFINES_ONLY,BOARD_PCA10040,NRF52832,NRF52,SPI0_ENABLED,DEBUG
  c include: ..\..\..\components\drivers_nrf\hal;..\..\..\components\drivers_nrf\common;..\ikm;..\bsp;..\..;..\..\..\components\libraries\util;..\..\..\components\drivers_nrf\config;..\..\..\components\drivers_nrf\nrf_soc_nosd;..\..\..\components\toolchain;..\config;..\..\..\components\drivers_nrf\spi_master;..\..\..\components\drivers_nrf\delay;..\..\..\components\libraries\log;..\..\..\components\libraries\log\src;..\..\..\components\oled
  library: MicroLIB
  memory RVCT4: ROM 0x1f000 size 0x61000
  memory RVCT9: RAM 0x20002128 size 0xded8
  group Application
    ./: main.c
  group nRF_Drivers
    ../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../components/libraries/util/: app_error.c nrf_assert.c app_error_weak.c
  group ikm_Drives
    ../../../components/oled/: oled.c oledfont.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.9.0
